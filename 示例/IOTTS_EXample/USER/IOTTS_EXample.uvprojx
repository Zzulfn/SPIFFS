# Keil uVision project IOTTS_EXample.uvprojx, settings and files
target IOTTS_EXample (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: IOTTS_EXample +hex
  c flags: Optim=1 uC99=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\CMSIS\CM3;..\CMSIS\CM3\CORE;..\CMSIS\CM3\STARTUP;..\CMSIS\STM32LIB\inc;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\HARDWARE;..\HARDWARE\LED;..\Com-Rule;..\HARDWARE\LCD;..\HARDWARE\AD9833;..\HARDWARE\KEY;..\Soft\Task;..\HARDWARE\TIMER;..\HARDWARE\MAX262;..\HARDWARE\PWM;..\HARDWARE\USART1;..\Soft;..\HARDWARE\CD4066;..\HARDWARE\MCP41010;..\HARDWARE\HT1622;..\HARDWARE\HT1381;..\HARDWARE\W25Q32;..\HARDWARE\74HC595;..\HARDWARE\74HC165;..\HARDWARE\UART4;..\HARDWARE\USART2;..\HARDWARE\USART3;..\HARDWARE\ADC;..\HARDWARE\DAC;..\HARDWARE\TIMER;..\SYSTEM\spiffs;..\Soft\Logic;..\HARDWARE\A3983
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group CMSIS
    ../CMSIS/CM3/CORE/: core_cm3.c
    ../CMSIS/CM3/: stm32f10x_it.c system_stm32f10x.c
    ../CMSIS/CM3/STARTUP/: startup_stm32f10x_hd.s
  group FWLIB
    ../CMSIS/STM32LIB/src/: misc.c stm32f10x_exti.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_flash.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_wwdg.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
  group USER
    ./: main.c
  group HARDWARE
    ../HARDWARE/LED/: bsp_led.c
    ../HARDWARE/W25Q32/: bsp_spi_flash.c
    ../HARDWARE/USART1/: bsp_usart1.c
  group SPIFFS
    ../SYSTEM/spiffs/: spiffs_cache.c spiffs_check.c spiffs_gc.c spiffs_hydrogen.c spiffs_nucleus.c spiffs_config.h
